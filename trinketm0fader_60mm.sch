File: trinketm0fader_60mm.sch (EAGLE design)
At the start: 11 parts, among them IC1 74AHCT1G125DBV

Commit message: cleanup
Other:
- note added: "TrinketM0"
- moved on the sheet: J1, J2, R1, R3, S1
